# Repository JordanAceto/fv1_breakout_board

File README.md:

# Small Spin Semi FV-1 breakout PCB

## [SCHEMATIC](https://github.com/JordanAceto/fv1_breakout_board/blob/main/construction_docs/fv1_breakout_board_schematic.pdf)

## Status of the project:

Task | Status |
---------|--------------|
Schematic capture | &#9745;
PCB layout | &#9745;
Test build | &#9745;
Safe to order boards| &#9745;

## KiCad design kicad_6_docs/fv1_board.kicad_pcb

Parts:
C1, C3, C13: 1u; C_0805_2012Metric
C2, C4: 1n COG; C_0805_2012Metric
C5, C6, C8, C15, C17, C19: 10u; C_0805_2012Metric
C7, C9: 2n2; C_0805_2012Metric
C10, C11, C12, C16, C18, C20, C21, C22, C23: 100n; C_0603_1608Metric
C14: 12p; C_0603_1608Metric
D1: D_Schottky; D_SOD-123
D2: LED; LED_1206_3216Metric
J1: signal_in; PinHeader_1x03_P2.54mm_Vertical
J2: signal_out; PinHeader_1x03_P2.54mm_Vertical
J3: cv_in; PinHeader_1x05_P2.54mm_Vertical
J4: prog_sel; PinHeader_1x04_P2.54mm_Vertical
J5: eeprom_prog_port; PinHeader_1x06_P2.54mm_Vertical
J6: DC_in; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R4, R6: 1k; R_0603_1608Metric
R3, R5, R9, R10, R11, R12, R13: 10k; R_0603_1608Metric
R7: 100; R_0603_1608Metric
R8, R14, R15: 2k2; R_0603_1608Metric
U1: spin_semi_fv1; SOIC-28W_7.5x17.9mm_P1.27mm
U2: 24LC32; DIP-8_W7.62mm_Socket
U3: L78L33_SO8; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 32768Hz; Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal

Connections:
+3V3: C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, D2.2 (A), J3.1, J5.5, R7.1, R9.1, R10.1, R11.1, R12.1, R14.1, R15.1, U1.6 (AVDD), U1.8 (DVDD), U1.23 (DVDD), U2.8 (VCC), U3.1 (OUT)
/EEPR_SEL: J5.4, R13.1, U2.1 (A0)
/SCK: J5.2, R15.2, U1.14 (SCK), U2.6 (SCL)
/SDA: J5.3, R14.2, U1.15 (SDA), U2.5 (SDA)
/T0: J5.1, R12.2, U1.13 (T0)
GND: C2.2, C4.2, C5.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, J1.3, J2.3, J3.5, J4.4, J5.6, J6.2, R3.2, R5.2, R13.2, U1.4 (GND), U1.7 (GND), U1.11 (GND), U1.12 (T1), U1.19 (GND), U1.24 (GND), U1.25 (REFN), U2.2 (A1), U2.3 (A2), U2.4 (GND), U2.7 (WP), U3.2 (GND), U3.3 (GND), U3.6 (GND), U3.7 (GND)
unnamed: C1.1, J1.1
unnamed: C1.2, R1.1
unnamed: C2.1, R1.2, U1.1 (LIN)
unnamed: C3.1, J1.2
unnamed: C3.2, R2.1
unnamed: C4.1, R2.2, U1.2 (RIN)
unnamed: C5.1, U1.3 (MID)
unnamed: C6.1, U1.28 (LOUT)
unnamed: C6.2, R3.1, R4.1
unnamed: C7.1, J2.1, R4.2
unnamed: C8.1, U1.27 (ROUT)
unnamed: C8.2, R5.1, R6.1
unnamed: C9.1, J2.2, R6.2
unnamed: C10.1, J3.2, U1.20 (POT0)
unnamed: C11.1, J3.3, U1.21 (POT1)
unnamed: C12.1, J3.4, U1.22 (POT2)
unnamed: C13.1, R7.2, U1.26 (REFP)
unnamed: C14.1, U1.9 (X2), Y1.2
unnamed: C15.1, C16.1, D1.1 (K), U3.8 (IN)
unnamed: D1.2 (A), J6.1
unnamed: D2.1 (K), R8.2
unnamed: J4.1, R9.2, U1.16 (S0)
unnamed: J4.2, R10.2, U1.17 (S1)
unnamed: J4.3, R11.2, U1.18 (S2)
unnamed: R8.1, U1.5 (CLIP)
unnamed: U1.10 (X1), Y1.1

Notes on the sheet:
(0 int, 1 ext)

Board: 4 copper layers, 33.0 x 50.8 mm, 50 parts (6 on the bottom side), 32 nets.

## Commit log

2022-01-14 add link to schematic
2023-03-04 Tick check boxes after successful test build

Notices in the files:
kicad_6_docs/fv1_board.kicad_pcb:
creativecommons.org/licenses/by-sa/4.0
License: CC-by-SA
